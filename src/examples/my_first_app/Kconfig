## src/examples/my_first_app/Kconfig
```kconfig
menuconfig EXAMPLES_MY_FIRST_APP
	bool "my_first_app"
	default n
	---help---
		Enable support for my_first_app
```
